Commit message: Add task

File: pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 4 links, 3 joints
Joints:
- joint joint_1: origin xyz=0.0 0 0 rpy=0 3.1415 0 -> xyz=0.0 0 0 rpy=0 3.14159265358979323846264338327950288419716939937510 0
